## drivers/input/fingerprint/Kconfig
```kconfig
source "drivers/input/fingerprint/fpc/Kconfig"
source "drivers/input/fingerprint/goodix/Kconfig"
```
